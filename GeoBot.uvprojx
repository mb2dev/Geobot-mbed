# Keil uVision project GeoBot.uvprojx, settings and files
target GeoBot (ARM-ADS)
  device: STM32L476RG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.pdsc
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: GeoBot
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTARGET_NUCLEO_L476RG -D__ASSERT_MSG -DTARGET_RELEASE -DMBED_BUILD_TIMESTAMP=1498295882.66 --no_rtti --split_sections -DTARGET_STM32L476xG -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DTARGET_STM32L476RG -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DTARGET_STM32L4 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DUSBHOST_OTHER -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; img; Shifting; Servo; mbed-os/.; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/mbedtls/targets; mbed-os/features/mbedtls/targets/TARGET_STM; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/features/filesystem; mbed-os/features/filesystem/bd; mbed-os/features/filesystem/fat; mbed-os/features/filesystem/fat/ChaN; mbed-os/cmsis; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/rtx; mbed-os/rtos/rtx/TARGET_CORTEX_M; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_STM; mbed-os/targets/TARGET_STM/TARGET_STM32L4; mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG; mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG; mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device; mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/TOOLCHAIN_ARM_STD; mbed-os/targets/TARGET_STM/TARGET_STM32L4/device;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/TOOLCHAIN_ARM_STD/stm32l476xx.sct
  group GeoBot
    ./: main.cpp mbed_config.h
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/features/mbedtls/targets/TARGET_STM/: aes_alt.c aes_alt.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.cpp Ethernet.h FileBase.cpp FileBase.h FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemLike.cpp FileSystemLike.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LocalFileSystem.cpp LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Stream.cpp Stream.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/: analogin_api.c analogout_api.c can_device.h common_objects.h device.h gpio_irq_device.c gpio_irq_device.h i2c_device.h mbed_overrides.c pin_device.h pwmout_device.c pwmout_device.h serial_api.c spi_api.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/platform/: Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed-os/targets/TARGET_STM/: can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_rtx.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h sleep.c stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-os/features/filesystem/fat/ChaN/: ccsbcs.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    mbed-os/features/netsocket/: CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.h stm32l476xx.h stm32l4xx.h system_stm32l4xx.h
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/: objects.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PeripheralNames.h PeripheralPins.c PinNames.h system_stm32l4xx.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/TOOLCHAIN_ARM_STD/: startup_stm32l476xx.S sys.cpp
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/device/: stm32_hal_legacy.h stm32l4xx_hal.c stm32l4xx_hal.h stm32l4xx_hal_adc.c stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.c stm32l4xx_hal_can.h stm32l4xx_hal_comp.c stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.c stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.c stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.c stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac_ex.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dma.c stm32l4xx_hal_dma.h stm32l4xx_hal_firewall.c stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.c stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.c stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hcd.c stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.c stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.c stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.c stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nand.h stm32l4xx_hal_nor.c stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.c stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.c stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.c stm32l4xx_hal_sai.h stm32l4xx_hal_sd.c stm32l4xx_hal_sd.h stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.c stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.c stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.c stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.c stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.c stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.c stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.c stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.c stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_crs.c stm32l4xx_ll_crs.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_dma.c stm32l4xx_ll_dma.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.c stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.c stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.c stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.c stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.c stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_usb.c stm32l4xx_ll_usb.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group Servo
    Servo/: Servo.cpp Servo.h
  group Shifting
    Shifting/: wheel.cpp wheel.h
